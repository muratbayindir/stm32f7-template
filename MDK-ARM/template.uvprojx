# Keil uVision project template.uvprojx, settings and files
target STM32F746G-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER STM32F746xx USE_STM32746G_DISCOVERY USE_USB_FS
  c include: ..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\STM32F746;..\Drivers\CMSIS\Include;..\Drivers\BSP\STM32746G-Discovery;..\Drivers\BSP\Components\Common;..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM7;..\Middlewares\FreeRTOS\CMSIS_RTOS;..\Middlewares\FreeRTOS\include;..\Middlewares\FatFs;..\Middlewares\STemWin\inc;..\Utilities\CPU;..\App\Core;..\App\emWin;..\App\FatFs;..\Middlewares\FatFs\drivers;..\App\FreeRTOS;..\App\ETH;..\Middlewares\LwIP\include;..\Middlewares\LwIP\system;..\Middlewares\STM32_USB_Host_Library\Core\Inc;..\Middlewares\STM32_USB_Host_Library\Class\MSC\Inc;..\App\USB_MSC;..\App\Audio
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x40000
  group Drivers/CMSIS/Device
    ../Drivers/CMSIS/Device/STM32F746/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group Drivers/BSP/STM32746G-Discovery
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/wm8994/: wm8994.c
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/Components/ov9655/: ov9655.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
  group Middlewares/FreeRTOS/portable
    ../Middlewares/FreeRTOS/portable/RVDS/ARM_CM7/: port.c
    ../Middlewares/FreeRTOS/portable/MemMang/: heap_5.c
  group Middlewares/FreeRTOS/CMSIS_RTOS
    ../Middlewares/FreeRTOS/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/STemWin/Lib
    ../Middlewares/STemWin/Lib/: STemWin540_CM7_OS_Keil.lib
  group Middlewares/STemWin/OS
    ../Middlewares/STemWin/OS/: GUI_X_OS.c
  group Utilities/CPU
    ../Utilities/CPU/: cpu_utils.c
  group Middlewares/FatFs
    ../Middlewares/FatFs/: diskio.c ff.c ff_gen_drv.c ffunicode.c
    ../Middlewares/FatFs/option/: syscall.c
  group Middlewares/FatFs/drivers
    ../Middlewares/FatFs/drivers/: sd_diskio_dma_rtos.c usbh_diskio_dma.c
  group Middlewares/LwIP/api
    ../Middlewares/LwIP/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c if_api.c
  group Middlewares/LwIP/core
    ../Middlewares/LwIP/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c altcp.c altcp_alloc.c altcp_tcp.c
  group Middlewares/LwIP/core/ipv4
    ../Middlewares/LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/LwIP/apps/httpd
    ../Middlewares/LwIP/apps/httpd/: fs.c httpd.c
  group Middlewares/LwIP/netif
    ../Middlewares/LwIP/netif/: ethernet.c bridgeif.c bridgeif_fdb.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group Middlewares/LwIP/system/OS
    ../Middlewares/LwIP/system/OS/: sys_arch.c
  group Middlewares/USB_HOST/Core
    ../Middlewares/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/USB_Host/Class/MSC
    ../Middlewares/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group App/Core
    ../App/Core/: main.c stm32f7xx_it.c
  group App/emWin
    ../App/emWin/: GUIConf.c LCDConf.c main_frame.c
  group App/FatFs
    ../App/FatFs/: SDApp.c
  group App/ETH
    ../App/ETH/: app_ethernet.c ethernetif.c httpserver-netconn.c
  group App/USB
    ../App/USB_MSC/: usbApp.c usbh_conf.c
  group App/Audio
    ../App/Audio/: waveplayer.c waverecorder.c
  group MDK-ARM
    ./: startup_stm32f746xx.s
