# Keil uVision project stm32f746g-template.uvprojx, settings and files
target STM32F746G-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: stm32f746g-template +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER STM32F746xx USE_STM32746G_DISCOVERY ARM_MATH_CM7 __FPU_PRESENT=1 USE_USB_HS
  c include: ..\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\Drivers\CMSIS\Include;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\BSP\STM32746G-Discovery;..\Drivers\BSP\Components\Common;..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1;..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\Middlewares\Third_Party\FreeRTOS\Source\include;..\Middlewares\Third_Party\FatFs\source;..\Middlewares\Third_Party\FatFs\source\drivers;..\Middlewares\Third_Party\LwIP\src\include;..\Middlewares\Third_Party\LwIP\src\system;..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\Middlewares\ST\STemWin\inc;..\Middlewares\ST\STemWin\Config;..\Utilities\CPU;..\Application\Audio;..\Application\Core;..\Application\emWin;..\Application\ETH;..\Application\SD;..\Application\USB
  asm include: ..\Middlewares\Third_Party\FreeRTOS\Source\portable\RVDS\ARM_CM7\r0p1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group CMSIS/Device
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_exti.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group Drivers/BSP/STM32746G-Discovery
    ../Drivers/BSP/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_audio.c stm32746g_discovery_camera.c stm32746g_discovery_eeprom.c stm32746g_discovery_lcd.c stm32746g_discovery_qspi.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c
  group Drivers/BSP/Components
    ../Drivers/BSP/Components/ft5336/: ft5336.c
    ../Drivers/BSP/Components/wm8994/: wm8994.c
    ../Drivers/BSP/Components/ov9655/: ov9655.c
  group Middlewares/Third_Party/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/Third_Party/FreeRTOS/portable
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_5.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM7/r0p1/: port.c
  group Middlewares/Third_Party/FreeRTOS/CMSIS_RTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Utilities/CPU
    ../Utilities/CPU/: cpu_utils.c
  group Middlewares/ST/STemWin/Config
    ../Middlewares/ST/STemWin/Config/: GUIConf.c LCDConf.c
  group Middlewares/ST/STemWin/OS
    ../Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/ST/STemWin/Lib
    ../Middlewares/ST/STemWin/Lib/: STemWin_CM7_OS_wc16.a
  group Middlewares/Third_Party/FatFs/
    ../Middlewares/Third_Party/FatFs/source/: diskio.c ff.c ff_gen_drv.c ffunicode.c
    ../Middlewares/Third_Party/FatFs/source/option/: syscall.c
  group Middlewares/Third_Party/FatFs/Drivers
    ../Middlewares/Third_Party/FatFs/source/drivers/: sd_diskio_dma_rtos.c usbh_diskio_dma.c
  group Middlewares/ST/STM32_USB_Host_Library/Core
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/ST/STM32_USB_Host_Library/Class/MSC
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Middlewares/Third_Party/LwIP/api
    ../Middlewares/Third_Party/LwIP/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group Middlewares/Third_Party/LwIP/core
    ../Middlewares/Third_Party/LwIP/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group Middlewares/Third_Party/LwIP/core/ipv4
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Middlewares/Third_Party/LwIP/apps/httpd
    ../Middlewares/Third_Party/LwIP/src/apps/httpd/: fs.c httpd.c
  group Middlewares/Third_Party/LwIP/netif
    ../Middlewares/Third_Party/LwIP/src/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group Application/Core
    ../Application/Core/: main.c stm32f7xx_hal_timebase_tim.c stm32f7xx_it.c
  group Application/emWin
    ../Application/emWin/: main_frame.c
  group Application/SD
    ../Application/SD/: SDApp.c
  group Application/USB
    ../Application/USB/: usbApp.c usbh_conf.c
  group Application/Audio
    ../Application/Audio/: waveplayer.c waverecorder.c
  group Application/ETH
    ../Application/ETH/: app_ethernet.c ethernetif.c httpserver-netconn.c
software components: CMSIS:CORE 5.1.2
